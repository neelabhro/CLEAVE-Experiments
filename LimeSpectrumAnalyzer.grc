options:
  parameters:
    generate_options: qt_gui
    id: a1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5240e6
  states: {}
- name: gain_db
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: samp_rate
    calibr_bandw_ch0: samp_rate
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: gain_db
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain_db
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
